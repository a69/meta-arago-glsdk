require kmscube.inc

SRC_URI = "git://git.ti.com/glsdk/kmscube.git;protocol=git"

S = "${WORKDIR}/git"

SRCREV = "5a03757c0aa52eff44fb0d8ac0529f8cc18b1da0"
